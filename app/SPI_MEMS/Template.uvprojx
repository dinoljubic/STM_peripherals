# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER
  c include: .\; Lib\CMSIS\Include; Lib\CMSIS\Device\ST\STM32F4xx\Include; Lib\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c l3gd20.c
  group STM_lib
    ./: STM_std_peripheral_lib_v1.8.0.lib
  group sys
    ./lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ./lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./lib/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
    ./: stm32f4xx_conf.h
  group Include
    ./: main.h l3gd20.h
  group Discovery Lib
    ./lib/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_l3gd20.c stm32f429i_discovery_l3gd20.h
software components: CMSIS:CORE 5.0.1
